# Keil uVision project FasterEdge-MCU-PY32F002A.uvproj, settings and files
target FasterEdge-MCU-PY32F002A (ARM-ADS)
  device: PY32F002Ax5 Puya
  cpu: IRAM(0x20000000-0x20000BFF) IROM(0x08000000-0x08004FFF) CLOCK(24000000)
  output: FasterEdge-MCU-PY32F002A +hex
  c define: PY32F002Ax5
  c include: ..\Core;..\Inc;..\User;..\Ability;..\Data
  group Core
    ../Core/: fe.c fe_hmac_sha256.c
  group Ability
    ../Ability/: ability_base.c ability_role.c ability_time.c ability_onekey.c ability_serial.c ability_modbus.c ability_reg.c ability_gpio.c
  group Data
    ../Data/: data_base.c data_config.c data_chip.c
  group User
    ../User/: main.c register.c fe_port.c
